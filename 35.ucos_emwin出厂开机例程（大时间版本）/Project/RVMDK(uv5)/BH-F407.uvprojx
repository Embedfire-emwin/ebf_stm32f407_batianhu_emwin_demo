# Keil uVision project BH-F407.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\uCOSIII\uC-CPU;..\..\uCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOSIII\uC-LIB;..\..\uCOSIII\uCOS-III\Source;..\..\uCOSIII\uCOS-III\Ports;..\..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\uCOSIII\os_cfg;..\..\STemWinLibrary532\inc;..\..\STemWinLibrary532\Config;..\..\STemWinLibrary532\PNG;..\..\User\FATFS;..\..\User\lwip-1.4.1\port;..\..\User\lwip-1.4.1\port\arch;..\..\User\lwip-1.4.1\port\Standalone;..\..\User\lwip-1.4.1\src\include;..\..\User\lwip-1.4.1\src\include\ipv4;..\..\User\lwip-1.4.1\src\include\lwip;..\..\User\lwip-1.4.1\src\include\netif;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\lwipapp;..\..\Demo;..\..\User\BSP\mpu6050\driver\include;..\..\User\BSP\mpu6050\driver\eMPL;..\..\User\BSP\mpu6050\driver\stm32L;..\..\User\BSP\mpu6050\eMPL-hal;..\..\User\BSP\mpu6050\mllite;..\..\User\BSP\mpu6050\mpl;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\User\USBAPP;..\..\User\mp3\pub;..\..\User\mp3\real
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\Template.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: stm32f4xx_it.c
  group APP
    ../../User/APP/: main.c appicon.c common.c desktop.c pysearch.c keypadapp.c rgbledDLG.c WeatherDLG.c CompassDLG.c ClockDLG.c NetworkDLG.c CameraDLG.c PictureDLG.c USBDLG.c MusicDLG.c RecorderDLG.c CalculatorDLG.c PhoneDLG.c MessageDLG.c
  group lwipAPP
    ../../User/lwipapp/: netconf.c tcp_echoclient.c tcp_echoserver.c udp_echoclient.c
  group USB_APP
    ../../User/USBAPP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group BSP
    ../../User/BSP/: bsp.c
    ../../User/BSP/led/: bsp_led.c bsp_color_led.c
    ../../User/BSP/font/: fonts.c
    ../../User/BSP/lcd/: bsp_ili9806g_lcd.c
    ../../User/BSP/usart/: bsp_debug_usart.c
    ../../User/BSP/touch/: bsp_i2c_touch.c gt5xx.c
    ../../User/BSP/sram/: bsp_sram.c
    ../../User/BSP/key/: bsp_key.c
    ../../User/BSP/TouchPad/: bsp_touchpad.c
    ../../User/BSP/beep/: bsp_beep.c
    ../../User/BSP/adc/: bsp_adc.c
    ../../User/BSP/DHT11/: bsp_dht11.c
    ../../User/BSP/DS18B20/: bsp_ds18b20.c
    ../../User/BSP/photoresister/: bsp_photoresister.c
    ../../User/BSP/RTC/: bsp_rtc.c
    ../../User/BSP/LAN8742A/: stm32f429_eth.c LAN8742A.c
    ../../User/BSP/camera/: bsp_ov2640.c ov5640_AF.c bsp_ov5640.c
    ../../User/BSP/wm8978/: bsp_wm8978.c
    ../../User/BSP/gsm_gprs/: bsp_gsm_gprs.c bsp_gsm_usart.c
  group BSP/MPU_driver
    ../../User/BSP/mpu6050/: bsp_mpu_exti.c mpu6050.c
    ../../User/BSP/i2c/: i2c.c
  group BSP/MPU_eMPL
    ../../User/BSP/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/BSP/mpu6050/driver/stm32L/: log_stm32.c
    ../../User/BSP/mpu6050/eMPL-hal/: eMPL_outputs.c
  group BSP/MPU_mllite
    ../../User/BSP/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group BSP/MPU_mpl
    ../../User/BSP/mpu6050/mpl/libmpllib_Keil_M4FP/: libmpllib.lib
  group USB_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group STemWin_V532
    ../../STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
    ../../STemWinLibrary532/PNG/: PNG.lib
    ../../STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIFont_Port.c GUIPicture_Port.c
    ../../STemWinLibrary532/OS/: GUI_X_OS.c
  group uC/CPU
    ../../uCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm cpu.h
  group uC/LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../uCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../uCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group os_cfg
    ../../uCOSIII/os_cfg/: os_cfg_app.h app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h
  group FatFs
    ../../User/FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c syscall.c
  group lwip
    ../../User/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../User/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../User/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../User/lwip-1.4.1/port/Standalone/: ethernetif.c
    ../../User/lwip-1.4.1/src/netif/: etharp.c
  group MP3Lib
    ../../User/mp3/: mp3tabs.c mp3dec.c
    ../../User/mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/mp3/real/arm/: asmpoly_thumb2.s asmmisc.s
  group DOC
    ../../Doc/: 必读说明.txt
